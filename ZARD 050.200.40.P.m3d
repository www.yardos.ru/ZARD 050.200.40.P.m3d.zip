# KOMPAS-3D part (ZARD 050.200.40.P.m3d)

Model tree:
1. Операция без истории:1
